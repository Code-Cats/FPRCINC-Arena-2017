# Keil uVision project Arena_Base_YuXin.uvprojx, settings and files
target Arena_Base_YuXin (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Arena_Base_YuXin +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\BASE_DRIVE;.\CORE;.\FWLIB\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\CONTROL_TASK;.\DATE_TASK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c Mydefine.h
  group BASE_DRIVE
    ./BASE_DRIVE/: timer.c led.c key.c can.c adc.c pwm.c
  group CONTROL_TASK
    ./CONTROL_TASK/: base_deal.c control.c
  group DATE_TASK
    ./DATE_TASK/: pid.c date_deal.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
